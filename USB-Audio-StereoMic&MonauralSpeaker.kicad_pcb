# Repository noriakinakagawa/USB-Audio-StereoMic-MonauralSpeaker

File README.md:

# USB-Audio-StereoMic-MonauralSpeaker
USB-Audioを利用したステレオマイク入力、モノラルスピーカ出力のKiCad基板データです。

## マイク
MEMSマイクを利用する設計になっています。
秋月電子通商で販売しているAE-SPU0414を最大ゲイン設定で接続すると丁度いい感じです。
ただし、ゲイン設定用コンデンサのバラツキのせいか、左右マイクのゲインが若干違う場合があります。
その時は、コンデンサを測定して差が少ないコンデンサに交換して下さい。

## 注意事項
ロボットに組み込むことを前提にした設計であり、USBコネクタはPH4ピンに変換しているので、ケーブル加工が必要です。

## KiCad design USB-Audio-StereoMic&MonauralSpeaker.kicad_pcb

Parts:
C1, C4, C5, C6, C7, C8, C9, C14: 1u; C_0603
C2, C3, C15: 10u; C_0603
C10, C11, C12, C13, C16, C17: 0.1u; C_0603
F1: 0ZCJ0050FF2G; R_1206
J1: S4B-PH; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J2, J3: SJ-2523-SMT-TR; CUI_SJ-2523-SMT-TR
J4: S2B-XH-A; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J5: SJ2-3593D-SMT-TR; CUI_SJ2-3593D-SMT-TR
JP1, JP2: JP; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R1, R2: 22; R_0603
R3: 2.2; R_0603
R4: 1.5k; R_0603
R5: 1M; R_0603
R6, R7, R8, R9: 10k; R_0603
R10, R11, R12, R13: 2k; R_0603_1608Metric
U1: USBLC6-2P6; SOT-666
U2: AP7365-33WG-7; SOT-753
U3: PCM2906CDBR
U4: TPA2006D1DRBR
Y1: 12MHz33pF; CSTNE12M0G550000R0

Connections:
+3V3: C5.1, C14.1, C15.1, R10.1, R11.1, R12.1, R13.1, U2.5 (VOUT), U4.6 (VDD)
EN: U2.3 (EN), U3.28 (*SSPND), U4.1 (*SHUTDOWN)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C12.1, C13.1, C14.2, C15.2, J1.4, J2.G, J3.G, J5.G, U1.2 (GND), U2.2 (GND), U3.4 (DGNDU), U3.11 (AGNDC), U3.18 (AGNDP), U3.22 (AGNDX), U3.26 (DGND), U4.7 (GND), U4.9 (EPAD), Y1.2
unnamed: C10.1, R6.2
unnamed: C10.2, J5.TN
unnamed: C11.1, J5.SN
unnamed: C11.2, R7.2
unnamed: C12.2, C13.2, R8.1, R9.1
unnamed: C16.2, J2.T, JP1.1, R12.2
unnamed: C17.2, J3.T, JP2.1, R13.2
unnamed: F1.2, J1.1
unnamed: J1.2, R2.2
unnamed: J1.3, R1.2
unnamed: J2.S, R10.2
unnamed: J3.S, R11.2
unnamed: J4.1, U4.5 (VO+)
unnamed: J4.2, U4.8 (VO-)
unnamed: C1.1, R3.1, U1.5 (VBUS), U3.3 (VBUS)
unnamed: R1.1, R4.2, U1.6 (I/O1), U3.1 (D+)
unnamed: R2.1, U1.4 (I/O2), U3.2 (D-)
unnamed: C9.1, R4.1, U3.8 (SEL0), U3.9 (SEL1), U3.27 (VDDI)
unnamed: C2.2, U3.10 (VCCCI)
unnamed: C8.1, U3.17 (VCCP1I)
unnamed: C7.1, U3.19 (VCCP2I)
unnamed: C6.1, U3.23 (VCCXI)
unnamed: C3.2, U3.14 (VCOM)
unnamed: C16.1, JP1.2, U3.12 (VINL)
unnamed: C17.1, JP2.2, U3.13 (VINR)
unnamed: J5.T, U3.16 (VOUTL)
unnamed: J5.S, U3.15 (VOUTR)
unnamed: R5.1, U3.21 (XTI), Y1.3
unnamed: R5.2, U3.20 (XTO), Y1.1
unnamed: R6.1, R7.1, U4.3 (IN+)
unnamed: R8.2, R9.2, U4.4 (IN-)
VBUS: C4.1, F1.1, R3.2, U2.1 (VIN)

Notes on the sheet:
Left mic unit
10pF to 33pF
ECM（エレクトレットコンデンサマイクロフォン）の使い方
Right mic unit

Board: 2 copper layers, 40.0 x 40.0 mm, 43 parts (0 on the bottom side), 35 nets.

## Commit log

2021-04-18 Add files
2025-05-09 市販のモノラルマイクに対応
